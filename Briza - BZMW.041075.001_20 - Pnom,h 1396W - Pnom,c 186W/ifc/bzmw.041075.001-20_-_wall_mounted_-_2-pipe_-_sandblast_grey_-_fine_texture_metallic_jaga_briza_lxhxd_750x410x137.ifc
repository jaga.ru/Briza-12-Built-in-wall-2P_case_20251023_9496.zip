Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-07T11:57:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1500(x64) - Exporter 18.4.0.0 - ARCHICAD Connection 21.0.0.6007
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 07 11:57:12 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{04916129-B61F-45FC-9409-70634C1C055F}\ifc * Database version: 5507 * Database creation date: Mon Jan 07 11:57:12 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 07 11:57:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 07 11:57:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection
2 x Port_309041 | SOURCEANDSINK
2 x Port_309041 | SINK
Port_309041 | SOURCE

# IfcEnergyConversionDevice: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137, RSen_55_ME_FB_fan coils - 2 pipes_jaga:bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137:309041
In: Level 1
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: RSen_x_rgb 161 161 160 T00 sanblast gray 001_gen
Type - Constraints - Default Elevation: 100 mm
Type - Construction - RSen_C_diameter_type: OD; RSen_C_diameter_type_index: 1; TBQen_C_SOg_01: standard; TBQen_C_SOg_02: none_gen
Type - Dimensions - RSen_C_depth: 137 mm; RSen_C_height: 410 mm; RSen_C_length: 750 mm
Type - Electrical - RSen_E_c01_apparent_power: 0 W; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: yes; RSen_E_c01_load_class: Other; RSen_E_c01_number_of_poles: 1; RSen_E_c01_power: 0 W; RSen_E_c01_power_factor: 1; RSen_E_c01_voltage: 24 V
Type - Identity Data - Description: jaga_briza_wall mounted; Manufacturer: Jaga; Model: Briza; RSen_C_code_article: BZMW.041075.001/20; RSen_C_code_ETIM: Air-conditioning split system – inside unit (evaporator); RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC011580&classVersion=4; RSen_C_code_product: FWM03DAF; RSen_C_code_product_class: FWM-DAF; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 31/07/2018; RSen_C_content_date_issue: 31/07/2018; RSen_C_content_provider: Jaga; RSen_C_content_version: 1.1.0; RSen_C_description: jaga_briza_wall mounted; RSen_C_IFC_version: 2x3; RSen_C_license: Creative Commons Attribution NoDerivs (CC-ND); RSen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSen_C_model: Briza; RSen_C_revit_version: 2016; RSen_C_type: 2-pipe; RSen_C_type_comments: Wall mounted; TBQ_I BaseKeynote: 55.10.10.10; Type Name: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137; URL: www.jaga.be
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 161 161 160 T00 sanblast gray 001_gen; TBQ_I Colour: sandblast grey - fine texture metallic; TBQ_I Colour chart: 1
Type - Mechanical - RSen_P_c01_volume_flow: 0 m3/s; RSen_P_c02_volume_flow: 0 m3/s; RSen_P_c05_load_value: 0; TBQ_I Air flow rate_high: 0 m3/s; TBQ_I Air flow rate_low: 0 m3/s; TBQ_I Air flow rate_nom: 0 m3/s
Type - Model Properties - TBQ_I Depth_cm: 13; TBQ_I Height_cm: 41; TBQ_I Length_cm: 75
Type - Other - Category: Mechanical Equipment; Family Name: RSen_55_ME_FB_fan coils - 2 pipes_jaga; RSen_E_c01_description: c01_el; RSen_E_c01_power_factor_state: Lagging; RSen_E_c01_system_type: Power - Balanced; RSen_E_c01_yes_no: yes; RSen_E_c02_description: c02_controls; RSen_E_c02_yes_no: yes; RSen_P_c01_description: c01_supply hydraulic connection; RSen_P_c01_diameter: 20 mm; RSen_P_c01_diameter_calc: 20 mm; RSen_P_c01_flow_configuration: Preset; RSen_P_c01_flow_direction: In; RSen_P_c01_loss_method: Not Defined; RSen_P_c01_system_classification: Hydronic Supply; RSen_P_c01_yes_no: yes; RSen_P_c02_description: c02_return hydraulic connection; RSen_P_c02_diameter: 20 mm; RSen_P_c02_diameter_calc: 20 mm; RSen_P_c02_flow_configuration: Preset; RSen_P_c02_flow_direction: Out; RSen_P_c02_loss_method: Not Defined; RSen_P_c02_system_classification: Hydronic Return; RSen_P_c02_yes_no: yes; RSen_P_c05_description: c05_drain piping connection; RSen_P_c05_diameter: 20 mm; RSen_P_c05_diameter_calc: 20 mm; RSen_P_c05_flow_configuration: Fixture Units; RSen_P_c05_flow_direction: Out; RSen_P_c05_loss_method: Not Defined; RSen_P_c05_system_classification: Sanitary; RSen_P_c05_yes_no: yes
Pset_DistributionFlowElementCommon - Reference: RSen_55_ME_FB_fan coils - 2 pipes_jaga:bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_ProductRequirements - Category: Mechanical Equipment
Constraints - Elevation: 0 mm; Host: Reference Plane : v_rightleft
Construction - RSen_C_accessory_ME_01: none_gen; RSen_C_alignment: Center; RSen_C_alignment_index: 0; RSen_C_connection_set_CHr: none; RSen_C_connection_set_CHs: none; RSen_C_suspension_height: 0 mm; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 10.9182 m2; Volume: 1.04897 m3
Graphics - RSen_C_clearance_zone: no; RSen_C_connection_zone: no; RSen_C_maintenance_zone: no; RSen_C_neighbour_unit: no; RSen_C_neighbour_unit_displacement_back: 0 mm; RSen_C_neighbour_unit_displacement_front: 0 mm; RSen_C_neighbour_unit_displacement_left: 0 mm; RSen_C_neighbour_unit_displacement_right: 0 mm; TBQen_C_logo: yes
Identity Data - Mark: 28
Mechanical - System Classification: Power,Controls,Sanitary,Hydronic Supply,Hydronic Return
Mechanical - Flow - RSen_M_air_flow_rate: Low; RSen_M_air_flow_rate_index: 0; RSen_M_flow_rate: 0 m3/s
Other - Family: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137; Family and Type: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137; Type: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137; Type Id: RSen_55_ME_FB_fan coils - 2 pipes_jaga: bzmw.041075.001/20 - wall mounted - 2-pipe - sandblast grey - fine texture metallic_jaga_briza_lxhxd 750x410x137
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: http://www.witas.be/en/daikin
